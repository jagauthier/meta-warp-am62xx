# Explicitly set S to ensure source is found
S = "${WORKDIR}/git"

