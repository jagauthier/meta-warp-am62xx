# Explicitly set S to ensure source is found
S = "${WORKDIR}/git"

# Use kernel 6.12 branch for TI kernel 6.12
BRANCH = "linuxws/scarthgap/k6.12/${PV}"
