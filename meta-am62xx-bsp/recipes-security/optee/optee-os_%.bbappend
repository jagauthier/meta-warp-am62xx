# This bbappend is only used for versions that don't have a specific recipe
# For optee-os_git.bb, we have a complete recipe that overrides meta-arm
# Note: Both optee-os-ti-version.inc and optee-os-ti-overrides.inc are included
# in optee-os_git.bb to avoid duplicate inclusion warnings
